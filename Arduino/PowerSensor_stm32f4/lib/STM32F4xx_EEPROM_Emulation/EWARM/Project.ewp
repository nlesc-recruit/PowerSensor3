# IAR project Project.ewp, settings and files
configuration STM324xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32f4xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_rcc.c
  group User
    ../src/: eeprom.c main.c stm32f4xx_it.c
